# Keil uVision project hid_demo.uvprojx, settings and files
target hid_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F425R8T7 ArteryTek
  pack: ArteryTek.AT32F425_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: hid_demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F425R8T7,USE_STDPERIPH_DRIVER,AT_START_F425_V1
  c include: ..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\at32f425_board;..\inc;..\..\..\..\..\..\middlewares\usb_drivers\inc;..\..\..\..\..\..\middlewares\usbh_class\usbh_hid
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../src/: at32f425_clock.c at32f425_int.c main.c usbh_user.c
  group bsp
    ../../../../../at32f425_board/: at32f425_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f425_crm.c at32f425_exint.c at32f425_gpio.c at32f425_misc.c at32f425_pwc.c at32f425_scfg.c at32f425_usart.c at32f425_usb.c at32f425_acc.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f425.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f425.s
  group usbh_driver
    ../../../../../../middlewares/usb_drivers/src/: usb_core.c usbh_core.c usbh_ctrl.c usbh_int.c
  group usbh_class
    ../../../../../../middlewares/usbh_class/usbh_hid/: usbh_hid_class.c usbh_hid_keyboard.c usbh_hid_mouse.c
  group readme
    ../: readme.txt
