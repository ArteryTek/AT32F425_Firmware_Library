# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: -AT32F425R8T7 ArteryTek
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: Template +hex
  c flags: Optim=1
  c define: AT32F425R8T7,USE_STDPERIPH_DRIVER,AT_START_F425_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\at32f425_board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../src/: at32f425_int.c at32f425_clock.c main.c
  group bsp
    ../../../at32f425_board/: at32f425_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f425.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f425.c
  group firmware
    ../../../../libraries/drivers/src/: at32f425_acc.c at32f425_adc.c at32f425_can.c at32f425_crc.c at32f425_crm.c at32f425_debug.c at32f425_dma.c at32f425_ertc.c at32f425_exint.c at32f425_flash.c at32f425_gpio.c at32f425_i2c.c at32f425_misc.c at32f425_pwc.c at32f425_scfg.c at32f425_spi.c at32f425_tmr.c at32f425_usart.c at32f425_usb.c at32f425_wdt.c at32f425_wwdt.c
  group readme
    ../: readme.txt
