# Keil uVision project run_in_boot_memory.uvprojx, settings and files
target run_in_boot_memory (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F425R8T7 ArteryTek
  pack: ArteryTek.AT32F425_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: run_in_boot_memory +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F425R8T7,USE_STDPERIPH_DRIVER,AT_START_F425_V1
  c include: ..\..\..\..\project\at32f425_board;..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\libraries\cmsis\cm4\core_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x1fffe400 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../src/: at32f425_clock.c at32f425_int.c main.c run_in_boot_memory.c
  group bsp
    ../../../../project/at32f425_board/: at32f425_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32f425_crm.c at32f425_gpio.c at32f425_usart.c at32f425_misc.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f425.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f425.c
  group readme
    ../: readme.txt
