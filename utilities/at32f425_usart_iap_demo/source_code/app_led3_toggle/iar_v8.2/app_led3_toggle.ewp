# IAR project app_led3_toggle.ewp, settings and files
configuration app_led3_toggle (ARM, debug)
  General.OGChipSelectEditMenu: AT32F425R8T7_v2 ArteryTek -AT32F425R8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F425R8T7; USE_STDPERIPH_DRIVER; AT_START_F425_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32f425_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app_led3_toggle.bin
  ILINK.IlinkOutputFile: app_led3_toggle.out
  ILINK.IlinkIcfFile: AT32F425x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../project/at32f425_board/: at32f425_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f425.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f425.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f425_crm.c at32f425_flash.c at32f425_gpio.c at32f425_misc.c at32f425_tmr.c at32f425_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f425_clock.c at32f425_int.c iap.c main.c tmr.c usart.c
